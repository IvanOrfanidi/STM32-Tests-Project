<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Communicator.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\Counter\EWARM\Counter.ewp</path>
    </project>
    <batchBuild />
</workspace>
