# IAR project Communicator.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073RZ ST STM32L073RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L073xx; __USE_DEBUG_UART__
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\Drivers; ..\Src; ..\Tools; ..\STM32_USB_Device_Library\Core\Inc; D:\Work Project\LoraWAN\Communicator\STM32_USB_Device_Library\Class\CDC\Inc; ..\Comm Protocol
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Lorawan.out
  ILINK.IlinkIcfFile: stm32l073xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Src/: main.cpp
  group Application/USB
    ../Src/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Communicator Protocol
    ../Comm Protocol/: elf.h modbus_elf.cpp modbus_elf.h
  group Drivers/ADC
    ../Drivers/: adc.c adc.h
  group Drivers/EEPROM
    ../Drivers/: eeprom.c eeprom.h
  group Drivers/GPIO
    ../Drivers/: gpio.c gpio.h
  group Drivers/RTC
    ../Drivers/: rtc.c rtc.h
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Drivers/UART
    ../Drivers/: uart.c uart.h
  group Drivers/USB_Device_Library
    ../STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Includes
    ../Inc/: main.h stm32l0xx_hal_conf.h
  group System
    ./: startup_stm32l073xx.s stm32l073xx_flash.icf
    ../Src/: stm32l0xx_it.c system.c system_stm32l0xx.c
  group Tools
    ../Tools/: crc.cpp printf-stdarg.c
