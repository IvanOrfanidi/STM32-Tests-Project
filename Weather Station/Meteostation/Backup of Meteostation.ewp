# IAR project Backup of Meteostation.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa050,Pe111,Pe546,
  ICCARM.CCIncludePath2: $PROJ_DIR$; Device Code; StdPeriphLib\inc; FreeRTOS\include; FreeRTOS; Driver Code; USB Code; STM32_USB-FS-Device_Driver\inc; LCD; Driver Code\onewire; SDCard; fatfs; fatfs\option; Debug Code; Driver Code\pressure; Driver Code\ADC; Driver Code\DHT; Driver Code\RTC; Driver Code\USART; Driver Code\ENC28J60; Driver Code\ENC28J60\uIP
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Meteostation.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: Meteostation.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: freertos_general.c includes.h main.c
  group ADC Code
    Driver Code/ADC/: adc_general.c adc_general.h
  group Debug Code
    Debug Code/: debug.c debug.h
  group Device Code
    Device Code/: platform_config.c stm32f10x_conf.h stm32f10x_it.c system_stm32f10x.c
  group Device Code/Startup Code
    Device Code/Startup Code/: startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_md.s
  group Driver Code/BMP180
    Driver Code/pressure/: bmp180.c bmp180.h
  group Driver Code/DHT11
    Driver Code/DHT/: dht11.c dht11.h
  group Driver Code/DS18B20
    Driver Code/onewire/: DS18B20.c DS18B20.h
  group Driver Code/ENC28J60
    Driver Code/ENC28J60/: enc28j60.c enc28j60.h
  group Driver Code/LCD
    LCD/: LCD.c LCD.h
  group Driver Code/RTC
    Driver Code/RTC/: calendar.c calendar.h rtc.c rtc.h
  group Driver Code/SDCard
    SDCard/: fatfs_diskio_sdcard_spi.c ffconf.h sdcard.c
  group Driver Code/TIMER
    Driver Code/: timer.c timer.h
  group Driver Code/USATR DMA
    Driver Code/USART/: USART.c USART.h
  group Ethernet Code
    Driver Code/ENC28J60/: clock-arch.c ethernet_general.c ethernet_general.h hello-world.c hello-world.h uip-conf.h
  group Ethernet Code/uIP
    Driver Code/ENC28J60/uIP/: psock.c pt.h timer_eth.c uip-fw.c uip-neighbor.c uip-split.c uip.c uip_arp.c uiplib.c
  group FreeRTOS
    FreeRTOS/source/: cmsis_os.c croutine.c event_groups.c heap_1.c heap_2.c heap_3.c heap_4.c list.c port.c queue.c tasks.c timers.c
    FreeRTOS/: FreeRTOSConfig.h portasm.s
  group Humidity Code
    Driver Code/DHT/: humidity_general.c humidity_general.h
  group LCD Code
    LCD/: lcd_general.c lcd_general.h
  group Onewire Code
    Driver Code/onewire/: onewire_general.c onewire_general.h
  group Pressure Code
    Driver Code/pressure/: pressure_general.c pressure_general.h
  group SDCard Code
    ./: sdcard_general.c sdcard_general.h
  group SDCard Code/FATFS
    fatfs/: ff.c
  group StdPeriphLib
    StdPeriphLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USB Code
    USB Code/: hw_config.c platform_config_usb.h usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USB Code/USB-FS-Device_Driver
    STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
