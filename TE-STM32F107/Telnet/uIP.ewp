# IAR project uIP.ewp, settings and files
configuration STM32F107 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107VC ST STM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_CL; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa050,Pe111,Pe546,
  ICCARM.CCIncludePath2: $PROJ_DIR$; StdPeriphLib\inc; StdPeriphLib\CMSIS\Include; FreeRTOS\include; FreeRTOS; Device Code; Device Code\Startup Code; USART; Debug Code; USB Code; STM32_USB-FS-Device_Driver\inc; RTC; STM32_ETH_Driver; uIP
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uIP.bin
  ILINK.IlinkOutputFile: debug.out
  ILINK.IlinkIcfFile: stm32f107.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: includes.h main.c stm32f103x8.icf stm32f103xB.icf
  group Debug Code
    Debug Code/: debug.c debug.h
  group Device Code
    Device Code/: platform_config.c stm32f10x_conf.h stm32f10x_it.c system_stm32f10x.c
  group Device Code/Startup Code
    Device Code/Startup Code/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_md.s
  group Driver Code/RTC
    RTC/: calendar.c rtc.c
  group Driver Code/UART
    USART/: USART.c USART.h
  group FreeRTOS
    FreeRTOS/source/: cmsis_os.c croutine.c event_groups.c heap_1.c heap_2.c heap_3.c heap_4.c list.c port.c queue.c tasks.c timers.c
    FreeRTOS/: FreeRTOSConfig.h portasm.s
  group StdPeriphLib
    StdPeriphLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32_ETH_Driver
    STM32_ETH_Driver/: stm32_eth.c
  group uIP
    uIP/: cgi.c fs.c httpd.c telnetd-shell.c telnetd.c uip.c uip_arch.c uip_arp.c uIPMain.c
  group USB Code
    USB Code/: hw_config.c platform_config_usb.h usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USB Code/USB-FS-Device_Driver
    STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
