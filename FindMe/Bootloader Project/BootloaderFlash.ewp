# IAR project BootloaderFlash.ewp, settings and files
configuration Bootloader FindMe4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151VB ST STM32L151VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; FM4; BOOTLOADER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; board; ..\General Project; ..\General Project\STM32L1xx_StdPeriph_Driver\inc; ..\General Project\Driver Code; ..\General Project\Tools Code; ..\General Project\System Core Code; ..\General Project\Device Code
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BootloaderFlash.hex
  ILINK.IlinkOutputFile: BootloaderFlash.out
  ILINK.IlinkIcfFile: config\stm32l1xx_flash.icf
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Bootloader FindMe3 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; FM3; BOOTLOADER
  group (top)
    ../General Project/: eeprom.h
    ./: main_bootloader.c
  group Device Code
    ../General Project/Device Code/: platform_config_fm3.h platform_config_fm4.h
  group Driver Code
    ../General Project/Driver Code/: EXT_FLASH_FM3.c EXT_FLASH_FM4.c int_eeprom.c INT_FLASH.c SPI.c
  group StdPeriph_Driver
    STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_iwdg.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_spi.c stm32l1xx_usart.c
    board/: stm32l1xx_conf.h
  group System Core Code/CMSIS
    board/: system_stm32l1xx.c
  group System Core Code/Linker
    config/: stm32l1xx_flash.icf
  group System Core Code/Startup Code
    board/: startup_stm32l1xx_md.s
  group System Core Code/Vectors
    board/: stm32l1xx_it.c stm32l1xx_it.h
  group Tools Code
    ../General Project/Tools Code/: crc16.c
