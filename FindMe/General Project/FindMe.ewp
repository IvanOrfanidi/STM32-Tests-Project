# IAR project FindMe.ewp, settings and files
configuration FindMe4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151CB ST STM32L151CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; FM4
  ICCARM.CCDiagSuppress: Pa050,
  ICCARM.CCIncludePath2: $PROJ_DIR$; System Core Code\Startup Code; System Core Code; STM32L1xx_StdPeriph_Driver\inc; FreeRTOS\include; FreeRTOS; Driver Code; Tools Code; GPS Code; Applications Code; Flash Code; Periph Code; GSM Code; Config Device Code; Protocol Code; Device Code; Drive Simple Code
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FindMe.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FindMe3 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_MD; FM3
  ICCARM.CCDiagSuppress: Pa050, Pe111, Pe520
  group (top)
    ./: main.c
  group Config Device Code
    Config Device Code/: cmd_commands.h cmd_func.c cmd_parser.c
  group Debug Code
    Applications Code/: debug.c debug.h
  group Device Code
    Device Code/: global_eep.c global_ram.c platform_config.c platform_config_fm3.h platform_config_fm4.h power.c test_device.c
  group Drive Simple Code
    Drive Simple Code/: drive_simple.c drive_simple.h
  group Driver Code
    Driver Code/: ACCEL2.c ADC_1.c EXT_FLASH_FM3.c EXT_FLASH_FM4.c int_eeprom.c INT_FLASH.c rtc.c SPI.c TIMER.c UART.c
  group Flash Code
    Flash Code/: flash_archive.c flash_general.c
  group FreeRTOS
    FreeRTOS/source/: cmsis_os.c croutine.c event_groups.c heap_1.c heap_2.c heap_3.c heap_4.c list.c port.c queue.c tasks.c timers.c
    FreeRTOS/: FreeRTOSConfig.h portasm.s
  group GPS Code
    GPS Code/: gps_general.c gps_parser_ver1.c gps_parser_ver2.c gps_tools.c
  group GSM Code
    GSM Code/: gsm_general.c
  group GSM Code/FM911
    GSM Code/: fm911.c
  group GSM Code/GSM/GPRS
    GSM Code/: gsm_gprs.c gsm_info.c gsm_mc52iT.c gsm_parser.c
  group GSM Code/HTTP
    GSM Code/: gsm_http.c gsm_http.h
  group GSM Code/ION
    GSM Code/: ion.c
  group GSM Code/SMS
    GSM Code/: gsm_sms.c sms_cmd.c
  group Includes
    ./: eeprom.h includes.h ram.h
  group Periph Code
    Periph Code/: periph_general.c periph_general.h
  group Protocol Code/911
    Protocol Code/: findme_911.c
  group Protocol Code/ION
    Protocol Code/: protocol_general.c protocol_realize.c
  group StdPeriph_Driver
    STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group System Core Code
    System Core Code/: stm32l1xx_conf.h system_stm32l1xx.c
  group System Core Code/Linker
    ./: stm32l1xx_flash.icf
  group System Core Code/Startup Code
    System Core Code/Startup Code/: startup_stm32l1xx_md.s
  group System Core Code/Vectors
    System Core Code/: stm32l1xx_it.c
  group Tools Code
    Driver Code/: calendar.c
    Tools Code/: crc16.c tools.c
