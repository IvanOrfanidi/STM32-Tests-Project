# IAR project Archery.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT
  ICCARM.CCDiagSuppress: Pa050,Pe111,Pe546,
  ICCARM.CCIncludePath2: $PROJ_DIR$; StdPeriphLib\inc; StdPeriphLib\CMSIS\Include; FreeRTOS\include; FreeRTOS; Device Code; Device Code\Startup Code; USB Code; STM32_USB-FS-Device_Driver\inc; ADXL345; SSD1306; ADC; UART
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Archery.bin
  ILINK.IlinkOutputFile: debug.out
  ILINK.IlinkIcfFile: stm32f103x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group Application
    ./: accel.c debug.c display.c main.c
  group Driver Code/Accelerometer
    ADXL345/: adxl345.c
  group Driver Code/ADC
    ADC/: adc.c
  group Driver Code/Display
    SSD1306/: fonts.c img.c ssd1306.c
  group Driver Code/UART
    UART/: uart.c
  group FreeRTOS
    FreeRTOS/source/: cmsis_os.c croutine.c event_groups.c heap_1.c heap_2.c heap_3.c heap_4.c list.c port.c queue.c tasks.c timers.c
    FreeRTOS/: FreeRTOSConfig.h portasm.s
  group Inc
    ./: includes.h
    Device Code/: platform_config.h stm32f10x_conf.h
  group StdPeriphLib
    StdPeriphLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System/Board
    Device Code/: platform_config.c
  group System/CMSIS
    Device Code/: system_stm32f10x.c
  group System/Linker
    ./: stm32f103x8.icf
  group System/Startup
    Device Code/Startup Code/: startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_md.s
  group System/Vectors
    Device Code/: stm32f10x_it.c
  group USB Code
    USB Code/: hw_config.c platform_config_usb.h usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USB Code/USB-FS-Device_Driver
    STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
