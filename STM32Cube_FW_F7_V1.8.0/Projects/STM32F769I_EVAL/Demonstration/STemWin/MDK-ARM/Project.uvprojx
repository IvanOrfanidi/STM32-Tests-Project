# Keil uVision project Project.uvprojx, settings and files
target STM32F769I-EVAL_Demo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I-EVAL_Demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F769xx,USE_HAL_DRIVER,USE_STM32F769I_EVAL,USE_USB_HS,USE_IOEXPANDER
  c include: ../Gui/STemWin_Addons;../Config;../Core/Inc;../Gui/Target;../../../../../Utilities/CPU;../../../../../Utilities/JPEG;../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32F769I_EVAL;../../../../../Drivers/BSP/Components;../../../../../Drivers/BSP/Components/Common;../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../../../../../Middlewares/ST/STemWin/inc;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/LwIP/src/include/;../../../../../Middlewares/Third_Party/LwIP/system;../../../../../Middlewares/Third_Party/LwIP/system/OS;../Modules/Common;../Modules/audio_player;../Modules/audio_recorder;../Modules/videoplayer;../Modules/vnc_server;../Modules/audio_player/Addons/SpiritDSP_Equalizer;../Modules/audio_player/Addons/SpiritDSP_LoudnessControl
  asm include: ../Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: STM32F769I-EVAL_Demo\Exe\STM32F769I-EVAL_Demo.sct
  group Doc
    ../: readme.txt
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: queue.c croutine.c list.c tasks.c timers.c event_groups.c
  group Application/User/Gui/home_alarme
    ../Gui/Core/home_alarme/: home_alarm_win.c
  group Application/User/Utilities
    ../../../../../Utilities/JPEG/: jpeg_utils.c
    ../../../../../Utilities/CPU/: cpu_utils.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFS/src/: ff_gen_drv.c diskio.c ff.c
  group Middlewares/STemWin/ST_GUI_Addons
    ../Gui/STemWin_Addons/: STM32769I_EVAL_STemWin_Addons_Keil.lib
  group Application/User/Core
    ../Core/Src/: k_menu.c k_module.c k_storage.c k_bsp.c stm32f7xx_it.c stm32f7xx_hal_timebase_tim.c main.c k_modules_res.c k_startup.c k_rtc.c
  group Application/User/Gui/audio_recorder
    ../Gui/Core/audio_recorder/: audio_recorder_win.c
  group Application/User/Modules/audio_recorder
    ../Modules/audio_recorder/: audio_recorder_app.c
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFS/src/option/: syscall.c unicode.c
  group Application/User/Gui/games
    ../Gui/Core/games/: games_win.c
  group Application/User/Modules/Common
    ../Modules/Common/: audio_if.c
  group Application/User/Gui/gardening_control
    ../Gui/Core/gardening_control/: gardening_control_win.c
  group Application/User/Modules/audio_player
    ../Modules/audio_player/: audio_player_app.c
  group Middlewares/LwIP/Api
    ../../../../../Middlewares/Third_Party/LwIP/src/api/: netifapi.c tcpip.c sockets.c netbuf.c api_lib.c api_msg.c err.c netdb.c
  group Middlewares/STemWin/OS
    ../../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Application/User/Modules/audio_player/Addons
    ../Modules/audio_player/Addons/SpiritDSP_Equalizer/: lib_equalizer_cortex_m4.a
    ../Modules/audio_player/Addons/SpiritDSP_LoudnessControl/: lib_loudness_cortex_m4.a
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Middlewares/FatFs/Drivers
    ../Config/: usbh_diskio.c
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Middlewares/STemWin/Library
    ../../../../../Middlewares/ST/STemWin/Lib/: STemWin540_CM7_OS_Keil_ot.lib
  group Drivers/STM32F7xx_HAL_Drivers
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dac.c stm32f7xx_hal_cec.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_wwdg.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_rng.c stm32f7xx_hal_nor.c stm32f7xx_hal_eth.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_sdram.c stm32f7xx_hal_uart.c stm32f7xx_hal_cryp.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_lptim.c stm32f7xx_hal_crc.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_mdios.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_usart.c stm32f7xx_hal_adc.c stm32f7xx_hal_flash.c stm32f7xx_hal_hash.c stm32f7xx_hal_hcd.c stm32f7xx_hal_smbus.c stm32f7xx_hal_irda.c stm32f7xx_hal_can.c stm32f7xx_hal_mmc.c stm32f7xx_hal_pcd.c stm32f7xx_hal_nand.c stm32f7xx_hal_gpio.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_i2s.c stm32f7xx_hal_dsi.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_i2c.c stm32f7xx_ll_usb.c stm32f7xx_hal_sd.c stm32f7xx_hal_tim.c stm32f7xx_hal_sai.c
  group Middlewares/PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/: libPDMFilter_CM7_Keil.lib
  group Middlewares/USBH_Library/Class/MSC
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc_scsi.c usbh_msc.c
  group Middlewares/LwIP/Core
    ../../../../../Middlewares/Third_Party/LwIP/src/core/: dns.c sys.c timeouts.c stats.c mem.c tcp_out.c tcp.c pbuf.c udp.c memp.c ip.c def.c init.c inet_chksum.c raw.c netif.c tcp_in.c
  group Drivers/BSP/STM32769I_EVAL
    ../../../../../Drivers/BSP/STM32F769I_EVAL/: stm32f769i_eval_io.c stm32f769i_eval.c stm32f769i_eval_nor.c stm32f769i_eval_sdram.c stm32f769i_eval_sd.c stm32f769i_eval_ts.c stm32f769i_eval_audio.c stm32f769i_eval_qspi.c
  group Application/User/Gui/videoplayer
    ../Gui/Core/videoplayer/: video_player_win.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/USBH_Library/Config
    ../Config/: usbh_conf.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c ip4.c dhcp.c autoip.c icmp.c ip4_frag.c etharp.c igmp.c
  group Middlewares/LwIP/Netif
    ../../../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
    ../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/USBH_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ioreq.c usbh_core.c usbh_pipes.c usbh_ctlreq.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Application/User/Gui/vnc_server
    ../Gui/Core/vnc_server/: vnc_server_win.c
  group Application/User/Gui/audio_player
    ../Gui/Core/audio_player/: audio_player_win.c
  group Middlewares/STemWin/Target
    ../Gui/Target/: LCDConf_CmdMode_TE.c GUIConf.c
  group Application/User/Modules/videoplayer
    ../Modules/videoplayer/: GUI_AVI.c video_player_app.c
  group Application/User/Modules/vnc_server
    ../Modules/vnc_server/: ethernetif.c vnc_app.c
  group Application/User/Gui/settings
    ../Gui/Core/settings/: settings_win.c
software components: CMSIS:CORE 4.3.0
