# IAR project Project.ewp, settings and files
configuration STM32F723E-DISCO_Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F723IE ST STM32F723IE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F723xx; USE_STM32F723E_DISCO; USE_USB_HS
  ICCARM.CCIncludePath2: ..\Gui\STemWin_Addons; ..\Gui\Target; ..\Config; ..\Core\Inc; ..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32F723E-Discovery; ..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\..\Middlewares\ST\STemWin\inc; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\Modules\Common; ..\Modules\audio_player; ..\Modules\audio_recorder; ..\Modules\videoplayer
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: STM32CubeDemo_STM32F723E-DISCO_V1.0.0.hex
  ILINK.IlinkOutputFile: STM32F723E-DISCO_Demo.out
  ILINK.IlinkIcfFile: stm32f723xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f723xx.s
  group Application/User/Core
    ../Core/Src/: k_bsp.c k_calibration.c k_menu.c k_module.c k_rtc.c k_startup.c k_storage.c main.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c
  group Application/User/Gui/analog_clock
    ../Gui/Core/analog_clock/: analog_clock_win.c
  group Application/User/Gui/audio_player
    ../Gui/Core/audio_player/: audio_player_win.c
  group Application/User/Gui/audio_recorder
    ../Gui/Core/audio_recorder/: audio_recorder_win.c
  group Application/User/Gui/information
    ../Gui/Core/information/: information_win.c
  group Application/User/Gui/videoplayer
    ../Gui/Core/videoplayer/: video_player_win.c
  group Application/User/Modules/Audio
    ../Modules/audio_player/: audio_player_app.c
  group Application/User/Modules/Audio_recorder
    ../Modules/audio_recorder/: audio_recorder_app.c
  group Application/User/Modules/common
    ../Modules/Common/: audio_if.c
  group Application/User/Modules/VideoPlayer
    ../Modules/videoplayer/: GUI_AVI.c
  group Application/User/Utilities
    ../../../../../Utilities/CPU/: cpu_utils.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
    ../../../../../Drivers/BSP/Components/st7789h2/: st7789h2.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/BSP/STM32723E_DISCO
    ../../../../../Drivers/BSP/STM32F723E-Discovery/: stm32f723e_discovery.c stm32f723e_discovery_audio.c stm32f723e_discovery_lcd.c stm32f723e_discovery_qspi.c stm32f723e_discovery_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Drivers
    ../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_ll_usb.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Config/: usbh_diskio.c
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Middlewares/PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/: libPDMFilter_CM7_IAR.a
  group Middlewares/STemWin/Config
    ../Gui/Target/: GUIConf.c LCDConf.c
  group Middlewares/STemWin/Library
    ../../../../../Middlewares/ST/STemWin/Lib/: STemWin540_CM7_OS_IAR_ot.a
  group Middlewares/STemWin/OS
    ../../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/STemWin/ST_GUI_Addons
    ../Gui/STemWin_Addons/: STM32F723E_DISCO_STemWin_Addons_IAR.a
  group Middlewares/USBH_Library/Class/MSC
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/USBH_Library/Config
    ../Config/: usbh_conf.c
  group Middlewares/USBH_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
