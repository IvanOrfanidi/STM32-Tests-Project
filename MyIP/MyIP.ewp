# IAR project MyIP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.CCIncludePath2: $PROJ_DIR$; System Core; System Core\Include; System Core\Startup; System Core\Vectors; StdPeriphLib\inc; Board; Drivers\EXTI; Drivers\RTC; Drivers\SPI; Drivers\VirtualPort; ENC28J60
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: MyIP.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: linker.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    ./: main.cpp
  group Board
    Board/: board.cpp board.hpp
  group Drivers/SPI
    Drivers/SPI/: spi.cpp spi.hpp
  group Drivers/VirtualPort
    Drivers/VirtualPort/: virtual_port.hpp
  group MyIP
    ENC28J60/: enc28j60.cpp enc28j60.hpp net.cpp net.hpp
  group StdPeriphLib
    StdPeriphLib/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c
  group System Core
    System Core/Startup/: system_stm32f10x.c
  group System Core/Startup
    System Core/Startup/: startup_stm32f10x_md.s
  group System Core/Vectors
    System Core/Vectors/: stm32f10x_it.c
