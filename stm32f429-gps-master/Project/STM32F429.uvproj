# Keil uVision project STM32F429.uvproj, settings and files
target USART_Library (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F429
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_DEFAULT_TIMEOUT_CALLBACK,__DBG_ITM,USE_STM32F429I_DISCO
  c include: ..\Project;..\mylibs;..\STM32F4xx_CMSIS;..\STM32F4xx_SPL;..\STM32F429I-Discovery;..\Common
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StartUp
    ./: startup_stm32f429_439xx.s system_stm32f4xx.c
  group user
    ./: main.c main.h
  group mylibs
    ../mylibs/: usartlib.c usartlib.h gps.c gps.h swo.c swo.h
  group STM32F4xx_CMSIS
    ../STM32F4xx_CMSIS/: core_cm4.h stm32f4xx_conf.h stm32f4xx.h
  group STM32F4xx_SPL
    ../STM32F4xx_SPL/: stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_fmc.c stm32f4xx_fmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h misc.c misc.h
  group STM32F429I-Discovery
    ../STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery.h stm32f429i_discovery_i2c_ee.c stm32f429i_discovery_i2c_ee.h stm32f429i_discovery_ioe.c stm32f429i_discovery_ioe.h stm32f429i_discovery_l3gd20.c stm32f429i_discovery_l3gd20.h stm32f429i_discovery_lcd.c stm32f429i_discovery_lcd.h stm32f429i_discovery_sdram.c stm32f429i_discovery_sdram.h
