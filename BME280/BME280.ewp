# IAR project BME280.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; System Core; System Core\Startup; System Core\Vectors; Board; System Core\Include; StdPeriphLib\inc; StdPeriphLib\src; bme280
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: linker.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    ./: main.cpp
  group BME280
    bme280/: bme280.cpp bme280.hpp
  group Board
    Board/: board.cpp
  group StdPeriphLib
    StdPeriphLib/src/: misc.c stm32f10x_bkp.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group System Core
    System Core/Startup/: system_stm32f10x.c
  group System Core/Startup
    System Core/Startup/: startup_stm32f10x_md.s
  group System Core/Vectors
    System Core/Vectors/: stm32f10x_it.c
