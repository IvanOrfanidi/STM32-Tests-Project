# IAR project NRF24L01_2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\System Core; ..\System Core\Startup; ..\System Core\Vectors; ..\System Core\Include; ..\StdPeriphLib\inc; Board; ..\Drivers\VirtualPort; ..\Drivers\UART; ..\Drivers\SPI; ..\Drivers\EXTI; ..\nrf24l01
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: linker.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; RELEASE
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\System Core; ..\System Core\Startup; ..\System Core\Vectors; ..\System Core\Include; ..\StdPeriphLib\inc; Board; ..\nrf24l01
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.cpp
  group Board
    Board/: board.cpp
  group Drivers/SPI
    ../Drivers/SPI/: spi.cpp spi.hpp
  group Drivers/UART
    ../Drivers/UART/: uart.cpp uart.hpp
  group Drivers/VirtualPort
    ../Drivers/VirtualPort/: virtual_port.hpp
  group NRF24L01
    ../nrf24l01/: nrf24l01.cpp nrf24l01.hpp
  group StdPeriphLib
    ../StdPeriphLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group System Core
    ../System Core/Startup/: system_stm32f10x.c
  group System Core/Startup
    ../System Core/Startup/: startup_stm32f10x_md.s
  group System Core/Vectors
    ../System Core/Vectors/: stm32f10x_it.c
