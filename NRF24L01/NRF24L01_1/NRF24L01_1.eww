<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\NRF24L01_1.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\NRF24L01_2\NRF24L01_2.ewp</path>
    </project>
    <batchBuild />
</workspace>
